# Keil uVision project YAM-Game.uvprojx, settings and files
target YAM-Game (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Game
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\FWLIB\inc;..\user;..\user\FreeRTOS\include;..\user\FreeRTOS\portable\RVDS\ARM_CM4F;..\user\DSP\Include;..\user\hardware\adc;..\user\hardware\can;..\user\hardware\buzzer;..\user\hardware\delay;..\user\hardware\key;..\user\hardware\led;..\user\hardware\limit;..\user\hardware\power_ctrl;..\user\hardware\rc;..\user\hardware\servo;..\user\hardware\timer;..\user\hardware\usart6;..\user\hardware\uart7;..\user\hardware\exit_init;..\user\hardware\sys;..\user\APP\CAN_receive;..\user\APP\chassis_task;..\user\APP\FreeRTOS_middleware;..\user\APP\pid;..\user\APP\remote_control;..\user\APP\start_task;..\user\mpu6050\eMPL;..\user\hardware\flash;..\user\hardware\laser;..\user\mpu6050;..\user\hardware\vision;..\user\DSP\Include;..\user\DSP;..\user\hardware\pid_control;..\user\hardware\motor_ctrl;..\user\APP\gimbal_task
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
  group FWILB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group APP
    ../user/APP/CAN_receive/: CAN_receive.c
    ../user/APP/chassis_task/: chassis_task.c
    ../user/APP/FreeRTOS_middleware/: FreeRTOS_middleware.c
    ../user/APP/pid/: pid.c
    ../user/APP/remote_control/: remote_control.c
    ../user/APP/start_task/: start_task.c
    ../user/APP/gimbal_task/: gimbal_task.c
  group startup
    ../startup/: startup_stm32f427xx.s
  group mpu6050
    ../user/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../user/mpu6050/: mpu6050.c myiic.c
  group hardware
    ../user/hardware/adc/: adc.c
    ../user/hardware/buzzer/: buzzer.c
    ../user/hardware/can/: can.c
    ../user/hardware/delay/: delay.c
    ../user/hardware/exit_init/: exit_init.c
    ../user/hardware/flash/: flash.c
    ../user/hardware/key/: key.c
    ../user/hardware/laser/: laser.c
    ../user/hardware/led/: led.c
    ../user/hardware/limit/: limit.c
    ../user/hardware/power_ctrl/: power_ctrl.c
    ../user/hardware/rc/: rc.c
    ../user/hardware/spi/: spi.c
    ../user/hardware/sys/: sys.c
    ../user/hardware/timer/: timer.c
    ../user/hardware/uart7/: uart7.c
    ../user/hardware/usart6/: usart6.c
    ../user/hardware/vision/: vision.c
    ../user/hardware/pid_control/: pid_control.c
    ../user/hardware/motor_ctrl/: motor_ctrl.c
    ../user/hardware/servo/: servo.c
  group user
    ../user/: crc.c kalman.c kalman_filter.c main.c
  group FreeRTOS
    ../user/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../user/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../user/FreeRTOS/portable/MemMang/: heap_4.c
  group DSP
    ../user/DSP/: arm_cortexM4lf_math.lib
